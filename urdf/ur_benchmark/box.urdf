Commit message: Modify box so that ball get be put inside.

File: urdf/ur_benchmark/box.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.002 0.082 0.08; collision box size=0.002 0.082 0.08
