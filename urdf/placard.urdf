Commit message: Make pole shorter.

File: urdf/placard.urdf (robot description, URDF)
Before this commit: robot placard, 1 links, 0 joints
Links:
- link placard: geometry collision cylinder length=1.4 radius=0.015; visual box size=0.01 0.4 0.3
